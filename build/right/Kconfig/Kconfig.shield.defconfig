## build/right/Kconfig/Kconfig.shield.defconfig
```kconfig
osource "/Users/qilewang/GithubRepos/Keyboards/zmk/app/boards/shields/*/Kconfig.defconfig"
```
